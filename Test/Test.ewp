# IAR project Test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\Micrium\uC-Config; ..\Micrium\uC-CPU; ..\Micrium\uC-CPU\ARM-Cortex-M3\IAR; ..\Micrium\uC-LIB; ..\Micrium\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\Micrium\uCOS-III\Source; ..\Micrium\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\STM32\inc; ..\STM32; APP; BSP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Test.srec
  ILINK.IlinkOutputFile: Test.out
  ILINK.IlinkIcfFile: Test.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: frame_188.h includes.h main.c serial.c serial.h spi_flash.c spi_flash.h stm32f10x_it.c stm32f10x_it.h tasks.c tasks.h
  group BSP
    BSP/: bsp.c bsp.h timestamp.c
  group Micrium/uC-Config
    ../Micrium/uC-Config/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h os_type.h
  group Micrium/uC-CPU
    ../Micrium/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group Micrium/uC-CPU/Port
    ../Micrium/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h cpu_a.asm cpu_c.c
  group Micrium/uC-LIB
    ../Micrium/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/uC-LIB/Port
    ../Micrium/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group Micrium/uCOS-III
    ../Micrium/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group Micrium/uCOS-III/Port
    ../Micrium/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group ST
    ../STM32/startup/iar/: startup_stm32f10x_md.s
    ../STM32/: stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group ST/inc
    ../STM32/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group ST/src
    ../STM32/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
